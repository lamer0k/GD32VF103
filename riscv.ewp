# IAR project riscv.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: GD32VF103V-EVAL GigaDevice GD32VF103V-EVAL
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 1
  ICCRISCV.CCOptLevel: 0
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  ICCRISCV.CCIncludePath2: ..\CortexLib\AbstractHardware\Registers; ..\CortexLib\AbstractHardware\Registers\GD32VF103; ..\CortexLib\AbstractHardware\Registers\GD32VF103\FieldValues; ..\CortexLib\Common; ..\CortexLib\rtos\Source; ..\CortexLib\rtos\Source\CriticalSection; ..\CortexLib\rtos\RISCV\GD32VF; Rtos\Config; $PROJ_DIR$; ..\CortexLib\AbstractHardware\Registers\RISCV32; ..\CortexLib\AbstractHardware\Registers\RISCV32\FieldValues; AbstractHardware\CoreRegisters; IarEvalGd32Kit; TimerService; AbstractHardware\Registers\CoreRegisters
  OBJCOPY.OOCOutputFile: riscv.srec
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: riscv.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 3
  group (top)
    ./: main.cpp teststates.hpp
  group Rtos/Config
    Rtos/Config/: taskerconfig.hpp taskertimersconfig.hpp
  group Rtos/RISCV/GD32VF
    ../CortexLib/rtos/RISCV/GD32VF/: interrupthandlers.cpp interrupthandlers.hpp
  group Rtos/Source
    ../CortexLib/rtos/Source/: coretypes.hpp idletask.hpp taskbase.hpp tasker.hpp taskerschedule.cpp taskertimer.hpp taskertimerservice.hpp taskertypes.hpp
  group Rtos/Source/CriticalSection
    ../CortexLib/rtos/Source/CriticalSection/: criticalregion.cpp criticalregion.hpp criticalsection.cpp criticalsection.hpp
  group TimerService
    TimerService/: softwaretimer.hpp timerservice.hpp
